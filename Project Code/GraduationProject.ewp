# IAR project GraduationProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GraduationProject.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: ADC_CONFIG.h ADC_INTERFACING.h ADC_PROG.C Common.h cstartup_M.c DIO_CONFIG.h DIO_INTERFACING.h DIO_PROG.c GLOBAL.h GPRS.c GPRS.h GPS.c GPS.h HeartSensor.c HeartSensor.h LcdD.c LcdD.h lm4f120h5qr.h main.c TempSen.c TempSen.h TIMER_CONFIG.h TIMER_INTERFACING.h TIMER_PROG.c TM4C123GH6PM.h UART_CONFIG.h UART_INTERFACING.h UART_PROG.c
